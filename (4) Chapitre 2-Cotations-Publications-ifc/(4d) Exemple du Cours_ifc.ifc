Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0], Option [Drawing Scale: 100.000000], Option [Global Unique Identifiers (GUID): Keep existing], Option [Elements to export: Filtered elements], Option [Partial Structure Display: Entire Model], Option [IFC Domain: All], Option [Structural Function: All Elements], Option [Convert Grid elements: On], Option [Convert IFC Annotations and ARCHICAD 2D elements: Off], Option [Convert 2D symbols of Doors and Windows: Off], Option [Explode Composite and Complex Profile elements into parts: Off], Option [Export geometries that Participates in Collision Detection only: Off], Option [Multi-skin complex geometries: Building element parts], Option [Elements in Solid Element Operations: Extruded/revolved], Option [Elements with junctions: Extruded/revolved without junctions], Option [Slabs with slanted edge(s): Extruded], Option [Use legacy geometric methods as in Coordination View 1.0: Off], Option [IFC Site Geometry: As boundary representation (BRep)], Option [IFC Site Location: At Project Origin], Option [Curtain Wall export mode: Container Element], Option [Railing export mode: Single Element], Option [Stair export mode: Container Element], Option [Properties To Export: All properties], Option [Space containment: Off], Option [Bounding Box: Off], Option [Geometry to type objects: Off], Option [Element Properties: Off], Option [Property Type Element Parameter: Off], Option [Quantity Type Element Parameter: Off], Option [IFC Base Quantities: Off], Option [Window Door Lining and Panel Parameters: On], Option [IFC Space boundaries: Off], Option [ARCHICAD Zone Categories as IFC Space classification data: Off], Option [Element Classifications: Off]
File name: C:\Users\FJ\Desktop\Vestiaire export ifc.ifc
Time: 2018-03-27T01:02:21
Author: #Nom maître oeuvre #Prénom maître oeuvre
Organization: #Societé maître oeuvre
Written by: The EXPRESS Data Manager Version 5.02.0100.09 : 26 Sep 2013
Made in: IFC file generated by GRAPHISOFT ARCHICAD-64 21.0.0 FRA FULL Windows version (IFC2x3 add-on version: 3005 FRA FULL).
Authorization: #Nom maître oeuvre #Prénom maître oeuvre

# IfcProject, NOM DU PROJET
Phase: #Provisoire

# IfcSite, Site
RefLatitude: 48, 52, 0, 0; RefLongitude: 2, 20, 0, 0; RefElevation: 26 m

# IfcBuildingStorey (4)
In: Bâtiment
Name | Elevation (m)
Toiture | 5.6
Etage 1er | 2.8
Rez-de-chaussée | 0
Sous-sol | -2.8

# IfcBuildingElementProxy: 1.2-Mur ext: revét ext + isol ext + maçonnerie + enduit 370 (8)
Material: Finition int - Enduit plâtre, Struct. - Parpaing béton, Isolation - Fibres de bois, Finition ext - Crépis
Pset_ConcreteElementGeneral - FireRating: Sans; ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0
Pset_FireRatingProperties - FireResistanceRating: Sans; IsCombustible: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name | In
MC_BRI_Ext-001 | Etage 1er
MC_BRI_Ext-002 | Etage 1er
MC_BRI_Ext-003 | Etage 1er
MC_BRI_Ext-004 | Etage 1er
MC_BRI_Ext-001 | Rez-de-chaussée
MC_BRI_Ext-002 | Rez-de-chaussée
MC_BRI_Ext-003 | Rez-de-chaussée
MC_BRI_Ext-004 | Rez-de-chaussée

# IfcBuildingElementProxy: 4.3-Cloison: isolation + plâtre 2 faces 100 (6)
In: Rez-de-chaussée
Material: Finition int - Plaque de plâtre (2), Cloison - Isolation
Pset_ConcreteElementGeneral - FireRating: Sans; ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0
Pset_FireRatingProperties - FireResistanceRating: Sans; IsCombustible: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
2 x CL_PLA_Isol_Int-001
CL_PLA_Isol_Int-002
CL_PLA_Isol_Int-003
CL_PLA_Isol_Int-004
CL_PLA_Isol_Int-005

# IfcBuildingElementProxy: 5.0-Dalle & Chape carrelée (Détaillé) 335, DC_BA_CARR-001
In: Rez-de-chaussée
Material: Finition int - Enduit plâtre, Struct. - B.A. coulé, Isolation Int. - Polyuréthane, Struct. - Chape, Finition sol - Carrelage
Pset_ConcreteElementGeneral - FireRating: Sans; ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0
Pset_FireRatingProperties - FireResistanceRating: Sans; IsCombustible: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Env. - Terre, Terrain-001
In: Rez-de-chaussée
Material: Env. - Terre
AC_Pset_RenovationAndPhasing - Renovation Status: Existing

# IfcBuildingElementProxy: Fenêtre coulissante 2 vantaux 21 (5)
In: Rez-de-chaussée
Material: Menuis1
Pset_ConcreteElementGeneral - ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0
Pset_PrecastConcreteElementGeneral - SerialNumber: Non défini
Pset_FireRatingProperties - IsCombustible: yes
Pset_ManufacturerTypeInformation - ModelLabel: Non défini
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
3 x Fen-001
2 x Fen-002

# IfcBuildingElementProxy: Porte 21 (5)
In: Rez-de-chaussée
Material: Menuis1
Pset_ConcreteElementGeneral - ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0
Pset_PrecastConcreteElementGeneral - SerialNumber: Non défini
Pset_FireRatingProperties - IsCombustible: yes
Pset_ManufacturerTypeInformation - ModelLabel: Non défini
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
Por-002
Por-001
Por-003
Por-005
Por-004

# IfcBuildingElementProxy: Struct. - Béton 200 (4)
In: Sous-sol
Material: Struct. - Béton
Pset_ConcreteElementGeneral - FireRating: Sans; ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0
Pset_FireRatingProperties - FireResistanceRating: Sans; IsCombustible: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
Name
MC_BRI_Ext-001
MC_BRI_Ext-002
MC_BRI_Ext-003
MC_BRI_Ext-004

# IfcBuildingElementProxy: Toiture - Tuile 150, Toit-01
In: Toiture
Material: Toiture - Tuile
Pset_ConcreteElementGeneral - FireRating: Sans; ServiceLife: 0 year; LifeCycleEnvironmentalLoad: 0
Pset_FireRatingProperties - FireResistanceRating: Sans; IsCombustible: yes
AC_Pset_RenovationAndPhasing - Renovation Status: Existing
